# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32L021C8T7 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.5
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, USE_STDPERIPH_DRIVER, AT32L021C8T7
  c include: ..\libraries\usbotg_library\inc;..\..\..\components\drivers\smp_call;..\libraries\AT32L021_Firmware_Library\cmsis\cm0plus\core_support;..\libraries\AT32L021_Firmware_Library\drivers\inc;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\cortex-m0;board\inc;..\..\..\components\libc\posix\io\poll;..\libraries\rt_drivers;..\..\..\include;board;..\..\..\components\drivers\include;..\libraries\rt_drivers\config;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\extension;..\libraries\AT32L021_Firmware_Library\cmsis\cm0plus\device_support;.;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;applications;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32L021_Firmware_Library/cmsis/cm0plus/device_support/startup/mdk/: startup_at32l021.s
    ../libraries/rt_drivers/: drv_common.c drv_flash.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/AT32L021_Firmware_Library/drivers/src/: at32l021_wwdt.c at32l021_spi.c at32l021_hwdiv.c at32l021_adc.c at32l021_exint.c at32l021_pwc.c at32l021_gpio.c at32l021_can.c at32l021_i2c.c at32l021_dma.c at32l021_wdt.c at32l021_tmr.c at32l021_crc.c at32l021_misc.c at32l021_usart.c at32l021_flash.c at32l021_scfg.c at32l021_crm.c at32l021_debug.c at32l021_ertc.c
    ../libraries/AT32L021_Firmware_Library/cmsis/cm0plus/device_support/: system_at32l021.c
